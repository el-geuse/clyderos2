Commit message: minor simulation changes

File: src/clyde_description/src/urdf/materials.xacro (robot description, xacro)
@@ -4,3 +4,6 @@
   <color rgba="0.700 0.700 0.700 1.000"/>
 </material>
+<material name="red">
+  <color rgba="1.000 0.000 0.000 1.000"/>
+</material>
 </robot>
